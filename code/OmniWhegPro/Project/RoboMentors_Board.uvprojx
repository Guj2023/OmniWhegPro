# Keil uVision project RoboMentors_Board.uvprojx, settings and files
target OmniWhegPro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: OmniWhegPro +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ..\Inc;..\Inc\hal_inc;..\Inc\m3_inc;..\Inc\os_inc;..\Inc\hal_inc\Legacy;..\User;..\User\algorithm;..\User\app;..\User\driver
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group driver
    ../User/: rm_hal_lib.h
    ../User/driver/: uart_device.c can_device.c
  group algorithm
    ../User/algorithm/: pid.c ramp.c
  group app
    ../User/: startup.c
    ../User/app/: study_task.c common.c servo_control.c
  group custom
    ../User/: sys.h
  group lib
    ../Inc/: stm32f4xx_it.c RoboMentors_Board1_3.lib
  group readme
    ../: README.md
software components: CMSIS:CORE 5.1.2
